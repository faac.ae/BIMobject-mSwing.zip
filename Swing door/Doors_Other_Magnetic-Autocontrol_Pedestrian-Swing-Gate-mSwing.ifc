Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Doors_Other_Magnetic-Autocontrol_Pedestrian-Swing-Gate-mSwing.ifc
Time: 2019-01-14T14:01:14
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Pedestrian Swing Gate mSwing
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Pedestrian Swing Gate mSwing; SKU (BO_prodsku): magnetic-mSwing; ManufacturName (BO_Manufac): Magnetic Autocontrol; BrandUrl (BO_brandurl): http://www.magnetic-access.com/; ProductFamily (BO_prodfam): FlowMotion; ProductGroup (BO_prodgroup): Pedestrian gates; ManufacturCountry (BO_mancont): Germany; DesignCountry (BO_designcont): Germany; PublishDate (BO_publisdat): 9/16/2018; EditionNumber (BO_edinum): 1; Width (BO_width): 1118; Height (BO_height): 1092; Depth (BO_depth): 180; Weight (BO_weight): 40; QR (BO_boqrurl): http://bimobject.com/magnetic-autocontrol/product/magnetic-mSwing; ProductDataUrl (BO_prodaturl): bimobject.com/magnetic-autocontrol/product/magnetic-mSwing; ProductUrl (BO_producturl): https://www.magnetic-access.com/en/products/pedestrian-gates/flowmotion.html; TechnicalDescription (BO_techcert): https://www.magnetic-access.com/en/products/pedestrian-gates/flowmotion.html; MaterialMain (BO_mainmat): Aluminium; MaterialSecondary (BO_secmat): Glass; BimObjectMainCategory (BO_bomaincat): Doors; BimObjectMainCategoryCode (BO_bomaincat_code): doors; BimObjectCategory (BO_bocat): Other; BimObjectCategoryCode (BO_bocat_code): doors-other; IfcClassification (BO_ifcclas): Furniture; Uniclass14Code (BO_uniclass_1_4_code): JW40; Uniclass14Description (BO_uniclass_1_4_desc): Access control systems; Uniclass20Code (BO_uniclass_2_0_code): SS-25-32-60; Uniclass20Description (BO_uniclass_2_0_desc): Pedestrian Access Point Control Barrier Systems; Uniclass2015Code (BO_uniclass2015_code): Ac_20_85_63; Uniclass2015Description (BO_uniclass2015_desc): Pedestrian security checking; NBSReference (BO_nbs_ref): 25-32-60; NBSReferenceDescription (BO_nbs_desc): Pedestrian Access Point Control Barrier Systems; MasterFormat2014Code (BO_masterformat2014_code): 11 14 13; MasterFormat2014Description (BO_masterformat2014_name): Pedestrian Gates; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IS, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, UA; RegionNorthAmerica (BO_northamerica): BS, BZ, CA, CR, CU, DO, GL, GT, HN, HT, JM, MX, NI, PA, PR, SV, TT, US; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): TF
